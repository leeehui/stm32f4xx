# Keil uVision project stm32f4-template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4-template
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\CMSIS\Include;.\CMSIS\Device\ST\STM32F4xx\Include;.\STM32F4xx_StdPeriph_Driver\inc;.\SRC;.\SRC\ws2812;.\SRC\Bsp\ETH;.\SRC\Bsp\systick;.\SRC\Bsp\usart;.\SRC\App;.\SRC\lwip-1.4.1\port\arch;.\SRC\lwip-1.4.1\port\Standalone;.\SRC\lwip-1.4.1\port;.\SRC\lwip-1.4.1\src\include\ipv4;.\SRC\lwip-1.4.1\src\include\lwip;.\SRC\lwip-1.4.1\src\include\netif;.\SRC\lwip-1.4.1\src\include;.\SRC\Bsp\uniqueID
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group SRC
    ./SRC/: main.c stm32f4xx_it.c system_stm32f4xx.c
    ./SRC/ws2812/: light_ws2812_cortex.c
    ./SRC/App/: netconf.c tcp_echoclient.c main-ethernet.c
  group CMSIS
    ./CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group STMF4xx_StdPeriph_Driver
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group BSP
    ./SRC/Bsp/ETH/: stm32f429_eth.c stm32f429_phy.c
    ./SRC/Bsp/key/: bsp_key.c
    ./SRC/Bsp/led/: bsp_led.c
    ./SRC/Bsp/systick/: bsp_SysTick.c
    ./SRC/Bsp/usart/: bsp_debug_usart.c
    ./SRC/Bsp/uniqueID/: bsp_unique_id.c
  group LwIP_src_api
    ./SRC/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP_src_core_ipv4
    ./SRC/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LwIP_src_core
    ./SRC/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LwIP_src_netif
    ./SRC/lwip-1.4.1/src/netif/: etharp.c
  group LwIP_port
    ./SRC/lwip-1.4.1/port/Standalone/: ethernetif.c
